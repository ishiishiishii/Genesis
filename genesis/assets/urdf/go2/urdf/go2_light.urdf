Commit message: Change base mass

File: genesis/assets/urdf/go2/urdf/go2_light.urdf (robot description, URDF)
Before this commit: robot go2_description, 29 links, 28 joints
Links:
- link base: mass 1.50 -> 0.50
